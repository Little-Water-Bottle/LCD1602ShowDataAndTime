# Keil uVision project LM016LTimeAndData.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: LM016LTimeAndData +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HardWare;..\LM016L显示时钟和日期
  group Source Group 1
    ./: main.c
  group HardWare
    ./HardWare/: LM016L.c Timer.c Data.c Button.c temp.c
